# Keil uVision project DWT_M4_TX.uvproj, settings and files
target DWT_M4_TX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M483KIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: DWT_M4_TX
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\Library\Device\Nuvoton\M480\Include;..\..\Library\StdDriver\inc;..\..\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group Library
    ../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c ecap.c epwm.c timer.c gpio.c eadc.c
  group User
    ../: main.c app_flash_config.c calibration.c efficiency.c hardware.c led.c modulation.c pid.c Qi_lp_filter.c Adc.c Isr.c Ask.c WPCQiTx_Standby.c Fsk.c WPCQiTx_TxState.c Pwm.c Coil.c Ble.c WPCQiTx.c
